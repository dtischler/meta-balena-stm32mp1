inherit kernel-resin
inherit kernel-devicetree

